[aimspice]
[description]
175

R1 1 2 122350
*DRAIN GATE SOURCE BULKN
MN1 2 2 0 0 NMOS L=1U W=5U

VDD 1 0 dc 1.8v

.plot id(MN1)

.include p18_model_card.inc
.include p18_cmos_models_tt.inc
[tran]
0.01n
60m
X
X
0
[ana]
4 1
0
1 1
1 1 -0.239382 0.0984556
5
Time
v(1)
v(mn1.drain)
v(mn1.source)
i(vdd)
[end]
